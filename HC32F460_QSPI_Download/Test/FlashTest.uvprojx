# Keil uVision project FlashTest.uvprojx, settings and files
target STM32F103 Flash Test (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Flash Algorithm Files
    ./: FlashDev.c FlashPrg.c
  group Source Files
    ./: FlashTest.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.4.0
