# Keil uVision project NewDevice.uvprojx, settings and files
target Cortex-M (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NewDevice +hex
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB
  c include: ..\HC32F460_QSPI_Download;.\W25Qxx_Driver\w25qxx\inc;.\W25Qxx_Driver\source;.\W25Qxx_Driver\bsp\ev_hc32f460_lqfp100_v1;.\W25Qxx_Driver\driver\inc;.\W25Qxx_Driver\mcu\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Driver
    ./W25Qxx_Driver/w25qxx/src/: w25qxx.c
    ./W25Qxx_Driver/driver/src/: hc32f460_clk.c hc32f460_utility.c hc32f460_gpio.c hc32f460_qspi.c hc32f460_pwc.c
    ./W25Qxx_Driver/mcu/common/: system_hc32f460.c
